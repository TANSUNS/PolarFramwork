# IAR project Standard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; ARM_MATH_CM3
  ICCARM.CCIncludePath2: ..\LIB\CMSIS\StartUp; ..\LIB\CMSIS\System; ..\LIB\inc; ..\LIB\src; ..\Users; ..\Apps; ..\Apps\BasicAlgrothem; ..\Apps\BasicDriver; ..\Apps\Com
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Standard.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APPS/BasicAlgrothem
    ../Apps/BasicAlgrothem/: Filter.c Filter.h FIR_Filter.c FIR_Filter.h PID.c PID.h
  group APPS/BasicDriver
    ../Apps/BasicDriver/: Polar_EXTI.c Polar_EXTI.h Polar_GPIO.c Polar_GPIO.h Polar_IT.c Polar_IT.h Polar_IT_Function.h
  group APPS/Com
    ../Apps/Com/: IncludeList.c IncludeList.h PeriphDef.h
  group CMSIS
    ../LIB/CMSIS/: core_cm3.c core_cm3.h
  group CMSIS/LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../LIB/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group CMSIS/StartUp
    ../LIB/CMSIS/StartUp/: startup_stm32f10x_hd.s
  group CMSIS/System
    ../LIB/CMSIS/: stm32f10x.h system_stm32f10x.h
    ../LIB/CMSIS/System/: system_stm32f10x.c
  group USERS
    ../Users/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
